# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ..\..\..\mcu\stm32h750vbt6\STM32H7xx_HAL_Driver\Inc;..\..\..\mcu\stm32h750vbt6\CMSIS\Include;..\..\..\mcu\stm32h750vbt6\CMSIS\Device\ST\STM32H7xx\Include;..\..\Middlewares\Third_Party\FreeRTOS\include;..\..\Middlewares\Third_Party\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\..\Middlewares\Third_Party\CMSIS-FreeRTOS\CMSIS\RTOS2\FreeRTOS\Include;..\..\Middlewares\Third_Party\CMSIS_5\CMSIS\RTOS2\Include;..\..\Middlewares\Third_Party\Printf;..\..\Middlewares\Third_Party\nanoMODBUS;..\..\usr\core\stm32h750vbt6;..\..\usr\app;..\..\usr\inc\stm32h750vbt6;..\..\usr\drivers\stm32h750vbt6;..\..\usr\device;..\..\usr\drivers;..\..\usr\common\filter;..\..\usr\common\ringbuffer;..\..\Middlewares\Third_Party\SystemView\SEGGER;..\..\Middlewares\Third_Party\SystemView\Sample\FreeRTOSV10.4;..\..\Middlewares\Third_Party\SystemView\Config
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group App
    ../../usr/app/: main.c app_digital_sample.c app_modbus_map.c app_sysview.c
  group Device
    ../../usr/device/: led.c relay.c modbus.c
  group Drivers\public
    ../../usr/drivers/: board.h drv_adc.h drv_gpio.h drv_system.h drv_uart.h
  group Drivers\stm32h750vbt6
    ../../usr/drivers/stm32h750vbt6/: board.c drv_system.c drv_adc.c drv_adc_desc.h drv_gpio.c drv_gpio_desc.h drv_uart.c drv_uart_desc.h
  group Common
    ../../usr/common/filter/: filter.c
    ../../usr/common/ringbuffer/: ringbuffer.c
  group Core\stm32h750vbt6
    ../../usr/core/stm32h750vbt6/: stm32h7xx_hal_msp.c stm32h7xx_it.c stm32h7xx_hal_timebase_tim.c
    ../../../mcu/stm32h750vbt6/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    ../../../mcu/stm32h750vbt6/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group Middlewares\Third_Party\RTOS
    ../../Middlewares/Third_Party/FreeRTOS/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c croutine.c
    ../../Middlewares/Third_Party/FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../Middlewares/Third_Party/FreeRTOS/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/CMSIS-FreeRTOS/CMSIS/RTOS2/FreeRTOS/Source/: cmsis_os2.c
    ../../Middlewares/Third_Party/CMSIS_5/CMSIS/RTOS2/Source/: os_systick.c
  group Middlewares\Third_Party\Printf
    ../../Middlewares/Third_Party/Printf/: printf.c
  group Middlewares\Third_Party\NanoModbus
    ../../Middlewares/Third_Party/nanoMODBUS/: nanomodbus.c
  group Middlewares\Third_Party\SystemView
    ../../Middlewares/Third_Party/SystemView/SEGGER/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c
    ../../Middlewares/Third_Party/SystemView/Sample/FreeRTOSV10.4/: SEGGER_SYSVIEW_FreeRTOS.c
  group Mcu\stm32h750vbt6
    ../../../mcu/stm32h750vbt6/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
